CMDLINE:append = " init=/usr/sbin/reconfig-clusterctrl ${CLUSTERCTRL_VARIANT}"